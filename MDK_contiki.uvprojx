# Keil uVision project MDK_contiki.uvprojx, settings and files
target MDK_contiki (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDK_contiki +hex
  BeforeMake: .\VER\pdinfo.exe .\VER\product_info.c
  AfterMake: fromelf.exe --bin -o ./Flash/hostnodev10_103.bin ./Flash/hostnodev10_103.axf
  AfterMake: .\tools\MakeCrcFile.exe ./Flash/hostnodev10_103.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER V10 AUTOSTART_ENABLE
  c include: .\USER_APP;.\RTE\CMSIS\INC;.\RTE\LIB\STM32F10x_StdPeriph_Driver\inc;.\RTE\CMSIS\Include;.\RTE\Device\STM32F103ZE\Include;.\BSP;.\VER;.\contiki-2.7\core;.\contiki-2.7\core\sys;.\contiki-2.7\core\lib;.\CPU;.\include;.\contiki-2.7\cpu\stm32w108
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT6: RAM 0x60000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./USER_APP/: contiki-main.c
  group Sys
    ./contiki-2.7/core/sys/: autostart.c etimer.c process.c timer.c
  group CPU
    ./contiki-2.7/cpu/arm/stm32f103/: clock.c
  group BSP
    ./BSP/: bsp.c LED.c USART.C SPI.c eeprom.c RTC.C Time.c
  group STM32F10x_StdPeriph_Driver
    ./RTE/LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_crc.c
  group Tools
    ./Tools/: tool.c
  group Version
    ./VER/: product_info.c
  group startup
    ./RTE/Device/STM32F103ZE/: system_stm32f10x.c startup_stm32f10x_hd.s
  group Documentation
    ./Documentation/: Abstract.txt problem.txt
